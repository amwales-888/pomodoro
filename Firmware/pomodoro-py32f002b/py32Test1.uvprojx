# Keil uVision project py32Test1.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: py32Test1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F002Bx5 USE_FULL_LL_DRIVER
  c include: .\User;.\System\PY32F002B_LL_Driver\Inc;.\System\CMSIS\Device\PY32F0xx\Include;.\System\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group User
    ./User/: py32f002b_it.c main.c main.h py32_assert.h py32f002b_it.h
  group System
    ./System/PY32F002B_LL_Driver/Src/: py32f002b_ll_gpio.c py32f002b_ll_rcc.c py32f002b_ll_utils.c py32f002b_ll_tim.c py32f002b_ll_exti.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
